`timescale 1ns/1ps
module tb_gain_lesson;
logic clk=0;always #10 clk=~clk;
logic reset=1,start=0,bypass=1,input_valid=0;logic[12:0]gain_q8=256;
logic[15:0]input_i=0,input_q=0;wire[15:0]output_i,output_q;wire output_valid;
wire[31:0]samples,pre_peak,pre_rails,post_peak,clips;wire[63:0]pre_power,post_power;
iq_gain_meter dut(.*);
initial begin $dumpfile("gain.vcd");$dumpvars(0,tb_gain_lesson);repeat(3)@(negedge clk);reset=0;
@(negedge clk);start=1;input_valid=0;bypass=1;gain_q8=256;@(negedge clk);start=0;
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2ee0 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2b4f || output_q!==16'h11f0)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2125 || output_q!==16'h2125)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h11f0 || output_q!==16'h2b4f)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h2ee0)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hee10 || output_q!==16'h2b4f)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hdedb || output_q!==16'h2125)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hd4b1 || output_q!==16'h11f0)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hd120 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hd4b1 || output_q!==16'hee10)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hdedb || output_q!==16'hdedb)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hee10 || output_q!==16'hd4b1)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'hd120)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h11f0 || output_q!==16'hd4b1)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2125 || output_q!==16'hdedb)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2b4f || output_q!==16'hee10)$fatal(1,"gain output");
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2ee0 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2b4f || output_q!==16'h11f0)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2125 || output_q!==16'h2125)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h11f0 || output_q!==16'h2b4f)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h2ee0)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hee10 || output_q!==16'h2b4f)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hdedb || output_q!==16'h2125)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hd4b1 || output_q!==16'h11f0)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hd120 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hd4b1 || output_q!==16'hee10)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hdedb || output_q!==16'hdedb)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hee10 || output_q!==16'hd4b1)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'hd120)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h11f0 || output_q!==16'hd4b1)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2125 || output_q!==16'hdedb)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h2b4f || output_q!==16'hee10)$fatal(1,"gain output");
input_valid=0;repeat(3)@(negedge clk);
if(samples!==64'd32)$fatal(1,"meter_samples");
if(pre_power!==64'd4608052128)$fatal(1,"pre_power");
if(pre_peak!==64'd144008033)$fatal(1,"pre_peak");
if(pre_rails!==64'd0)$fatal(1,"pre_rails");
if(post_power!==64'd4608052128)$fatal(1,"post_power");
if(post_peak!==64'd144008033)$fatal(1,"post_peak");
if(clips!==64'd0)$fatal(1,"gain_clips");
repeat(8)@(negedge clk);
@(negedge clk);start=1;input_valid=0;bypass=0;gain_q8=128;@(negedge clk);start=0;
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h1770 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h15a8 || output_q!==16'h08f8)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h1093 || output_q!==16'h1093)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h08f8 || output_q!==16'h15a8)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h1770)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hf708 || output_q!==16'h15a8)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hef6e || output_q!==16'h1093)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hea59 || output_q!==16'h08f8)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'he890 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hea59 || output_q!==16'hf708)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hef6e || output_q!==16'hef6e)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hf708 || output_q!==16'hea59)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'he890)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h08f8 || output_q!==16'hea59)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h1093 || output_q!==16'hef6e)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h15a8 || output_q!==16'hf708)$fatal(1,"gain output");
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h1770 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h15a8 || output_q!==16'h08f8)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h1093 || output_q!==16'h1093)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h08f8 || output_q!==16'h15a8)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h1770)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hf708 || output_q!==16'h15a8)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hef6e || output_q!==16'h1093)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hea59 || output_q!==16'h08f8)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'he890 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hea59 || output_q!==16'hf708)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hef6e || output_q!==16'hef6e)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hf708 || output_q!==16'hea59)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'he890)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h08f8 || output_q!==16'hea59)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h1093 || output_q!==16'hef6e)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h15a8 || output_q!==16'hf708)$fatal(1,"gain output");
input_valid=0;repeat(3)@(negedge clk);
if(samples!==64'd32)$fatal(1,"meter_samples");
if(pre_power!==64'd4608052128)$fatal(1,"pre_power");
if(pre_peak!==64'd144008033)$fatal(1,"pre_peak");
if(pre_rails!==64'd0)$fatal(1,"pre_rails");
if(post_power!==64'd1152013040)$fatal(1,"post_power");
if(post_peak!==64'd36007552)$fatal(1,"post_peak");
if(clips!==64'd0)$fatal(1,"gain_clips");
repeat(8)@(negedge clk);
@(negedge clk);start=1;input_valid=0;bypass=0;gain_q8=512;@(negedge clk);start=0;
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h5dc0 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h569e || output_q!==16'h23e0)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h424a || output_q!==16'h424a)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h23e0 || output_q!==16'h569e)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h5dc0)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hdc20 || output_q!==16'h569e)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hbdb6 || output_q!==16'h424a)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'ha962 || output_q!==16'h23e0)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'ha240 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'ha962 || output_q!==16'hdc20)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hbdb6 || output_q!==16'hbdb6)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hdc20 || output_q!==16'ha962)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'ha240)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h23e0 || output_q!==16'ha962)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h424a || output_q!==16'hbdb6)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h569e || output_q!==16'hdc20)$fatal(1,"gain output");
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h5dc0 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h569e || output_q!==16'h23e0)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h424a || output_q!==16'h424a)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h23e0 || output_q!==16'h569e)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h5dc0)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hdc20 || output_q!==16'h569e)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hbdb6 || output_q!==16'h424a)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'ha962 || output_q!==16'h23e0)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'ha240 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'ha962 || output_q!==16'hdc20)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hbdb6 || output_q!==16'hbdb6)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'hdc20 || output_q!==16'ha962)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'ha240)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h23e0 || output_q!==16'ha962)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h424a || output_q!==16'hbdb6)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h569e || output_q!==16'hdc20)$fatal(1,"gain output");
input_valid=0;repeat(3)@(negedge clk);
if(samples!==64'd32)$fatal(1,"meter_samples");
if(pre_power!==64'd4608052128)$fatal(1,"pre_power");
if(pre_peak!==64'd144008033)$fatal(1,"pre_peak");
if(pre_rails!==64'd0)$fatal(1,"pre_rails");
if(post_power!==64'd18432208512)$fatal(1,"post_power");
if(post_peak!==64'd576032132)$fatal(1,"post_peak");
if(clips!==64'd0)$fatal(1,"gain_clips");
repeat(8)@(negedge clk);
@(negedge clk);start=1;input_valid=0;bypass=0;gain_q8=4096;@(negedge clk);start=0;
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h7fff)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h8000 || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h8000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h7fff || output_q!==16'h8000)$fatal(1,"gain output");
input_valid=0;repeat(3)@(negedge clk);
if(samples!==64'd32)$fatal(1,"meter_samples");
if(pre_power!==64'd4608052128)$fatal(1,"pre_power");
if(pre_peak!==64'd144008033)$fatal(1,"pre_peak");
if(pre_rails!==64'd0)$fatal(1,"pre_rails");
if(post_power!==64'd60127707164)$fatal(1,"post_power");
if(post_peak!==64'd2147483648)$fatal(1,"post_peak");
if(clips!==64'd32)$fatal(1,"gain_clips");
repeat(8)@(negedge clk);
@(negedge clk);start=1;input_valid=0;bypass=0;gain_q8=0;@(negedge clk);start=0;
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2ee0;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'h2ee0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'h2b4f;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'h2125;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'h11f0;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd120;input_q=16'h0000;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hd4b1;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hdedb;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'hee10;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h0000;input_q=16'hd120;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h11f0;input_q=16'hd4b1;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2125;input_q=16'hdedb;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_i=16'h2b4f;input_q=16'hee10;input_valid=1;@(negedge clk);if(!output_valid || output_i!==16'h0000 || output_q!==16'h0000)$fatal(1,"gain output");
input_valid=0;repeat(3)@(negedge clk);
if(samples!==64'd32)$fatal(1,"meter_samples");
if(pre_power!==64'd4608052128)$fatal(1,"pre_power");
if(pre_peak!==64'd144008033)$fatal(1,"pre_peak");
if(pre_rails!==64'd0)$fatal(1,"pre_rails");
if(post_power!==64'd0)$fatal(1,"post_power");
if(post_peak!==64'd0)$fatal(1,"post_peak");
if(clips!==64'd0)$fatal(1,"gain_clips");
repeat(8)@(negedge clk);
$display("PASS gain teaching: bypass, half, double, saturation, zero; all integers and meters");$finish;end
endmodule
